## drivers/Kconfig
```kconfig
append_menu "Device Drivers"

if ARCH_TEGRA
source "drivers/bpmp-host-proxy/Kconfig"
source "drivers/bpmp-guest-proxy/Kconfig"
endif

endmenu
```
